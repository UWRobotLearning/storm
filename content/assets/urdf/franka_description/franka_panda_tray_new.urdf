Commit message: working on tray collisiion spheres

File: content/assets/urdf/franka_description/franka_panda_tray_new.urdf (robot description, URDF)
Before this commit: robot panda, 15 links, 14 joints
Links:
- link tray_link: geometry visual box size=0.25 0.245 0.04

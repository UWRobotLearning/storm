Commit message: added tray urdf and config

File: content/assets/urdf/franka_description/franka_panda_tray.urdf (robot description, URDF)
Before this commit: robot panda, 12 links, 11 joints
Links:
- link tray_link: geometry collision box size=0.25 0.245 0.01; visual box size=0.25 0.245 0.01
